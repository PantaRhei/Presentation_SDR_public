options:
  parameters:
    author: poneymagic
    generate_options: qt_gui
    id: fm_receiver
    output_language: python
    title: fm_receiver
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: channel_freq + center_offset
  states: {}
- name: center_offset
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: channel_freq_range
  states: {}
- name: channel_freq_range
  id: variable_qtgui_range
  parameters:
    label: channel_freq_range
    rangeType: int
    start: '88000000'
    step: '100000'
    stop: '111000000'
    value: '88000000'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq - channel_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: '480000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '75000'
    decim: '40'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Atténuation des hauts fréquence
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    name: '"Frequency sink hackrf"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: channel_freq
    fftsize: '1024'
    grid: 'True'
    name: '"Frequency sink with cos"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
